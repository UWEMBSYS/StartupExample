# IAR project StartupExample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302xC ST STM32F302xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: StartupExample.bin
  ILINK.IlinkOutputFile: StartupExample.out
  ILINK.IlinkIcfFile: C:\Users\silver\Projects\EMBSYS\StartupExample\startupexample.icf
  ILINK.IlinkProgramEntryLabel: InitializeDataSection
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group docs
    ./: README.md
  group Inc
    inc/: clocks.h pinmux.h stm32f401.h
  group Layout
    ./: startupexample.icf
  group Src
    src/: clocks.c datainit.c main.c pinmux.c startup.s
